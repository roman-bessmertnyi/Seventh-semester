# Keil uVision project State_TIM.uvprojx, settings and files
target State_TIM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: State_TIM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\system;.\lib\GPIO;.\lib\delay;.\lib\interrupt;.\lib\timer;.\lib\USART;.\lib\math
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ./system/: main.cpp Singletons.cpp Singletons.h State.cpp State.h Configuration.h Interrupt.cpp Interrupt.h UserInterrupt.cpp UserInterrupt.h
  group Lib
    ./lib/GPIO/: GPIO.cpp GPIO.h
    ./lib/timer/: Timer.cpp Timer.h
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
