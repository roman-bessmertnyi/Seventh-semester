# Keil uVision project usart_reseive_int.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usart_reseive_int
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\_lib_brown_delay;.\_lib_usart;.\_lib_tim_1637;.\_lib_usart_pc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    ./_lib_brown_delay/: brown_delay.c brown_delay.h
    ./_lib_tim_1637/: tm1637.h tm1637.c
    ./_lib_usart/: usart_lib.c usart_lib.h
    ./_lib_usart_pc/: pc_usart.c pc_usart.h
software components: CMSIS:CORE 5.1.2, CMSIS Driver:I2C 2.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
