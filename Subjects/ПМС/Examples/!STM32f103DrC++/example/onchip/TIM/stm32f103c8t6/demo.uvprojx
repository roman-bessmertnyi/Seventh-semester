# Keil uVision project demo.uvprojx, settings and files
target demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\lib\onchip\USART;..\..\..\..\lib\onchip\GPIO;..\..\..\..\lib\math;..\..\..\..\lib\onchip\interrupt;..\..\..\..\lib\onchip\timer;.\system;..\..\..\..\lib\onchip\delay
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../../lib/onchip/timer/: Timer.cpp
    ../../../../lib/onchip/delay/: Delay.cpp
    ./system/: Interrupt.cpp
  group system
    ./system/: main.cpp Configuration.h UserInterrupt.cpp UserInterrupt.h
software components: CMSIS:CORE 3.40.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
